# Keil uVision project EPD-nRF51.uvprojx, settings and files
target nRF51822_xxAA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EPD-nRF51 +hex
  AfterMake: ..\tools\make-ota-nrf51.bat $L @L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: BLE_STACK_SUPPORT_REQD NRF51822 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT NRF_DFU_SETTINGS_VERSION=1 SWI_DISABLE0 USE_APP_CONFIG
  c misc: --locale=english
  c include: ..\;..\EPD;..\GUI;..\SDK\12.3.0_d7731ad;..\SDK\12.3.0_d7731ad\components\toolchain;..\SDK\12.3.0_d7731ad\components\toolchain\cmsis\include;..\SDK\12.3.0_d7731ad\components\drivers_nrf\clock;..\SDK\12.3.0_d7731ad\components\drivers_nrf\common;..\SDK\12.3.0_d7731ad\components\drivers_nrf\delay;..\SDK\12.3.0_d7731ad\components\drivers_nrf\gpiote;..\SDK\12.3.0_d7731ad\components\drivers_nrf\hal;..\SDK\12.3.0_d7731ad\components\drivers_nrf\spi_master;..\SDK\12.3.0_d7731ad\components\drivers_nrf\twi_master;..\SDK\12.3.0_d7731ad\components\drivers_nrf\wdt;..\SDK\12.3.0_d7731ad\external\segger_rtt;..\SDK\12.3.0_d7731ad\components\libraries\bootloader\dfu;..\SDK\12.3.0_d7731ad\components\libraries\crc32;..\SDK\12.3.0_d7731ad\components\libraries\fds;..\SDK\12.3.0_d7731ad\components\libraries\fstorage;..\SDK\12.3.0_d7731ad\components\libraries\experimental_section_vars;..\SDK\12.3.0_d7731ad\components\libraries\log;..\SDK\12.3.0_d7731ad\components\libraries\log\src;..\SDK\12.3.0_d7731ad\components\libraries\pwr_mgmt;..\SDK\12.3.0_d7731ad\components\libraries\scheduler;..\SDK\12.3.0_d7731ad\components\libraries\trace;..\SDK\12.3.0_d7731ad\components\libraries\timer;..\SDK\12.3.0_d7731ad\components\libraries\util;..\SDK\12.3.0_d7731ad\components\ble\common;..\SDK\12.3.0_d7731ad\components\ble\ble_advertising;..\SDK\12.3.0_d7731ad\components\ble\ble_services\ble_dfu;..\SDK\12.3.0_d7731ad\components\softdevice\common\softdevice_handler;..\SDK\12.3.0_d7731ad\components\softdevice\s130\headers;..\SDK\12.3.0_d7731ad\components\softdevice\s130\headers\nrf51
  asm define: BLE_STACK_SUPPORT_REQD NRF51822 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT NRF_DFU_SETTINGS_VERSION=1 SWI_DISABLE0 __STARTUP_CONFIG
  asm misc: --cpreproc --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF51822,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DNRF51,-DSOFTDEVICE_PRESENT,-DNRF_DFU_SETTINGS_VERSION=1,-DSWI_DISABLE0,-D__STARTUP_CONFIG=__STARTUP_CONFIG
  asm include: ..\;..\config;..\EPD;..\GUI;..\SDK\12.3.0_d7731ad;..\SDK\12.3.0_d7731ad\components\toolchain;..\SDK\12.3.0_d7731ad\components\toolchain\cmsis\include;..\SDK\12.3.0_d7731ad\components\drivers_nrf\clock;..\SDK\12.3.0_d7731ad\components\drivers_nrf\common;..\SDK\12.3.0_d7731ad\components\drivers_nrf\delay;..\SDK\12.3.0_d7731ad\components\drivers_nrf\gpiote;..\SDK\12.3.0_d7731ad\components\drivers_nrf\hal;..\SDK\12.3.0_d7731ad\components\drivers_nrf\spi_master;..\SDK\12.3.0_d7731ad\components\drivers_nrf\twi_master;..\SDK\12.3.0_d7731ad\external\segger_rtt;..\SDK\12.3.0_d7731ad\components\libraries\fds;..\SDK\12.3.0_d7731ad\components\libraries\fstorage;..\SDK\12.3.0_d7731ad\components\libraries\experimental_section_vars;..\SDK\12.3.0_d7731ad\components\libraries\log;..\SDK\12.3.0_d7731ad\components\libraries\log\src;..\SDK\12.3.0_d7731ad\components\libraries\pwr_mgmt;..\SDK\12.3.0_d7731ad\components\libraries\scheduler;..\SDK\12.3.0_d7731ad\components\libraries\trace;..\SDK\12.3.0_d7731ad\components\libraries\timer;..\SDK\12.3.0_d7731ad\components\libraries\util;..\SDK\12.3.0_d7731ad\components\ble\common;..\SDK\12.3.0_d7731ad\components\ble\ble_advertising;..\SDK\12.3.0_d7731ad\components\softdevice\common\softdevice_handler;..\SDK\12.3.0_d7731ad\components\softdevice\s130\headers;..\SDK\12.3.0_d7731ad\components\softdevice\s130\headers\nrf51
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001ff8 size 0x2008
  link misc: --diag_suppress 6330
  group App
    ../: main.c app_config.h
    ../SDK/12.3.0_d7731ad/: sdk_config.h
  group EPD
    ../EPD/: EPD_config.c EPD_driver.c EPD_service.c UC81xx.c SSD16xx.c
  group GUI
    ../GUI/: GUI.c Lunar.c fonts.c u8g2_font.c Adafruit_GFX.c
  group nRF_BLE
    ../SDK/12.3.0_d7731ad/components/ble/ble_advertising/: ble_advertising.c
    ../SDK/12.3.0_d7731ad/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../SDK/12.3.0_d7731ad/components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Bootloader
    ../SDK/12.3.0_d7731ad/components/libraries/bootloader/dfu/: nrf_dfu_settings.c
    ../SDK/12.3.0_d7731ad/dfu/: nrf_dfu_flash_buttonless.c
  group nRF_Drivers
    ../SDK/12.3.0_d7731ad/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../SDK/12.3.0_d7731ad/components/drivers_nrf/common/: nrf_drv_common.c
    ../SDK/12.3.0_d7731ad/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../SDK/12.3.0_d7731ad/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../SDK/12.3.0_d7731ad/components/drivers_nrf/wdt/: nrf_drv_wdt.c
  group nRF_Libraries
    ../SDK/12.3.0_d7731ad/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c
    ../SDK/12.3.0_d7731ad/components/libraries/scheduler/: app_scheduler.c
    ../SDK/12.3.0_d7731ad/components/libraries/timer/: app_timer.c
    ../SDK/12.3.0_d7731ad/components/libraries/crc32/: crc32.c
    ../SDK/12.3.0_d7731ad/components/libraries/fstorage/: fstorage.c
    ../SDK/12.3.0_d7731ad/components/libraries/fds/: fds.c
    ../SDK/12.3.0_d7731ad/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
  group nRF_Log
    ../SDK/12.3.0_d7731ad/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../SDK/12.3.0_d7731ad/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../SDK/12.3.0_d7731ad/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Startup
    ../SDK/12.3.0_d7731ad/components/toolchain/arm/: arm_startup_nrf51.s
    ../SDK/12.3.0_d7731ad/components/toolchain/: system_nrf51.c
target flash_softdevice (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s130_nrf51_2.0.1_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: BLE_STACK_SUPPORT_REQD NRF51822 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x2018
