# Keil uVision project DFU-nRF52.uvprojx, settings and files
target nrf52811_xxaa_s112 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IROM(0x00000000,0x30000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") CLOCK(64000000) ELITTLE
  output: bl_nrf52811_xxaa_s112 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52840 FLOAT_ABI_SOFT NRF52811_XXAA NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 __STACK_SIZE=2048 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1 USE_APP_CONFIG
  c misc: --reduce_paths
  c include: ..\;..\SDK\17.1.0_ddde560\dfu;..\SDK\17.1.0_ddde560\components\ble\common;..\SDK\17.1.0_ddde560\components\boards;..\SDK\17.1.0_ddde560\components\libraries\atomic;..\SDK\17.1.0_ddde560\components\libraries\atomic_fifo;..\SDK\17.1.0_ddde560\components\libraries\balloc;..\SDK\17.1.0_ddde560\components\libraries\bootloader;..\SDK\17.1.0_ddde560\components\libraries\bootloader\ble_dfu;..\SDK\17.1.0_ddde560\components\libraries\bootloader\dfu;..\SDK\17.1.0_ddde560\components\libraries\crc32;..\SDK\17.1.0_ddde560\components\libraries\crypto;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\cc310;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\cc310_bl;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\cifra;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\mbedtls;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\micro_ecc;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\nrf_hw;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\nrf_sw;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\oberon;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\optiga;..\SDK\17.1.0_ddde560\components\libraries\delay;..\SDK\17.1.0_ddde560\components\libraries\experimental_section_vars;..\SDK\17.1.0_ddde560\components\libraries\fstorage;..\SDK\17.1.0_ddde560\components\libraries\log;..\SDK\17.1.0_ddde560\components\libraries\log\src;..\SDK\17.1.0_ddde560\components\libraries\mem_manager;..\SDK\17.1.0_ddde560\components\libraries\memobj;..\SDK\17.1.0_ddde560\components\libraries\queue;..\SDK\17.1.0_ddde560\components\libraries\ringbuf;..\SDK\17.1.0_ddde560\components\libraries\scheduler;..\SDK\17.1.0_ddde560\components\libraries\sha256;..\SDK\17.1.0_ddde560\components\libraries\stack_info;..\SDK\17.1.0_ddde560\components\libraries\strerror;..\SDK\17.1.0_ddde560\components\libraries\svc;..\SDK\17.1.0_ddde560\components\libraries\util;..\SDK\17.1.0_ddde560\components\softdevice\common;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers\nrf52;..\SDK\17.1.0_ddde560\components\toolchain\cmsis\include;..\SDK\17.1.0_ddde560\external\micro-ecc\micro-ecc;..\SDK\17.1.0_ddde560\external\nano-pb;..\SDK\17.1.0_ddde560\external\nrf_oberon;..\SDK\17.1.0_ddde560\external\nrf_oberon\include;..\SDK\17.1.0_ddde560\integration\nrfx;..\SDK\17.1.0_ddde560\modules\nrfx;..\SDK\17.1.0_ddde560\modules\nrfx\hal;..\config
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52840 FLOAT_ABI_SOFT NRF52811_XXAA NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 __STACK_SIZE=2048 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DDEVELOP_IN_NRF52840,-DFLOAT_ABI_SOFT,-DNRF52811_XXAA,-DNRFX_COREDEP_DELAY_US_LOOP_CYCLES=3,-DNRF_DFU_SETTINGS_VERSION=2,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=7,-DS112,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-D__HEAP_SIZE=0,-D__STACK_SIZE=2048,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: ..\SDK\17.1.0_ddde560\dfu;..\SDK\17.1.0_ddde560\components\ble\common;..\SDK\17.1.0_ddde560\components\boards;..\SDK\17.1.0_ddde560\components\libraries\atomic;..\SDK\17.1.0_ddde560\components\libraries\atomic_fifo;..\SDK\17.1.0_ddde560\components\libraries\balloc;..\SDK\17.1.0_ddde560\components\libraries\bootloader;..\SDK\17.1.0_ddde560\components\libraries\bootloader\ble_dfu;..\SDK\17.1.0_ddde560\components\libraries\bootloader\dfu;..\SDK\17.1.0_ddde560\components\libraries\crc32;..\SDK\17.1.0_ddde560\components\libraries\crypto;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\cc310;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\cc310_bl;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\cifra;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\mbedtls;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\micro_ecc;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\nrf_hw;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\nrf_sw;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\oberon;..\SDK\17.1.0_ddde560\components\libraries\crypto\backend\optiga;..\SDK\17.1.0_ddde560\components\libraries\delay;..\SDK\17.1.0_ddde560\components\libraries\experimental_section_vars;..\SDK\17.1.0_ddde560\components\libraries\fstorage;..\SDK\17.1.0_ddde560\components\libraries\log;..\SDK\17.1.0_ddde560\components\libraries\log\src;..\SDK\17.1.0_ddde560\components\libraries\mem_manager;..\SDK\17.1.0_ddde560\components\libraries\memobj;..\SDK\17.1.0_ddde560\components\libraries\queue;..\SDK\17.1.0_ddde560\components\libraries\ringbuf;..\SDK\17.1.0_ddde560\components\libraries\scheduler;..\SDK\17.1.0_ddde560\components\libraries\sha256;..\SDK\17.1.0_ddde560\components\libraries\stack_info;..\SDK\17.1.0_ddde560\components\libraries\strerror;..\SDK\17.1.0_ddde560\components\libraries\svc;..\SDK\17.1.0_ddde560\components\libraries\util;..\SDK\17.1.0_ddde560\components\softdevice\common;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers\nrf52;..\SDK\17.1.0_ddde560\external\micro-ecc\micro-ecc;..\SDK\17.1.0_ddde560\external\nano-pb;..\SDK\17.1.0_ddde560\external\nrf_oberon;..\SDK\17.1.0_ddde560\external\nrf_oberon\include;..\SDK\17.1.0_ddde560\integration\nrfx;..\SDK\17.1.0_ddde560\modules\nrfx;..\SDK\17.1.0_ddde560\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x29000 size 0x5000
  memory RVCT9: RAM 0x200022c8 size 0x3d38
  link misc: --diag_suppress 6330
  group Application
    ../SDK/17.1.0_ddde560/dfu/: dfu_public_key.c main.c sdk_config.h
    ../: app_config.h
  group Board Definition
    ../SDK/17.1.0_ddde560/components/boards/: boards.c
  group nRF_BLE
    ../SDK/17.1.0_ddde560/components/ble/common/: ble_srv_common.c
  group nRF_Bootloader
    ../SDK/17.1.0_ddde560/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../SDK/17.1.0_ddde560/components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../SDK/17.1.0_ddde560/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend nRF sw
    ../SDK/17.1.0_ddde560/components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend uECC
    ../SDK/17.1.0_ddde560/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../SDK/17.1.0_ddde560/components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ../SDK/17.1.0_ddde560/components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_Drivers
    ../SDK/17.1.0_ddde560/modules/nrfx/hal/: nrf_nvmc.c
    ../SDK/17.1.0_ddde560/modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../SDK/17.1.0_ddde560/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../SDK/17.1.0_ddde560/components/libraries/scheduler/: app_scheduler.c
    ../SDK/17.1.0_ddde560/components/libraries/crc32/: crc32.c
    ../SDK/17.1.0_ddde560/components/libraries/mem_manager/: mem_manager.c
    ../SDK/17.1.0_ddde560/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../SDK/17.1.0_ddde560/components/libraries/atomic/: nrf_atomic.c
    ../SDK/17.1.0_ddde560/components/libraries/balloc/: nrf_balloc.c
    ../SDK/17.1.0_ddde560/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../SDK/17.1.0_ddde560/components/libraries/queue/: nrf_queue.c
    ../SDK/17.1.0_ddde560/components/libraries/ringbuf/: nrf_ringbuf.c
    ../SDK/17.1.0_ddde560/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../SDK/17.1.0_ddde560/components/libraries/strerror/: nrf_strerror.c
    ../SDK/17.1.0_ddde560/components/libraries/sha256/: sha256.c
  group nRF_Oberon_Crypto
    ../SDK/17.1.0_ddde560/external/nrf_oberon/lib/cortex-m4/soft-float/short-wchar/: oberon_3.0.8.lib
  group nRF_SVC
    ../SDK/17.1.0_ddde560/components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../SDK/17.1.0_ddde560/components/libraries/svc/: nrf_svc_handler.c
  group nRF_SoftDevice
    ../SDK/17.1.0_ddde560/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_micro-ecc
    ../SDK/17.1.0_ddde560/external/micro-ecc/nrf52nf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../SDK/17.1.0_ddde560/external/nano-pb/: pb_common.c pb_decode.c
  group Startup
    ../SDK/17.1.0_ddde560/modules/nrfx/mdk/: arm_startup_nrf52811.s system_nrf52.c
