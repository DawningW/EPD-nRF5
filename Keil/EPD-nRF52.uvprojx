# Keil uVision project EPD-nRF52.uvprojx, settings and files
target nRF52811_xxAA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IRAM(0x20000000,0x00006000) IRAM2(0x00800000,0x00006000) IROM(0x00000000,0x00030000) CPUTYPE("Cortex-M4") DSP CLOCK(12000000) ELITTLE
  output: EPD-nRF52 +hex
  AfterMake: ..\tools\make-ota-nrf52.bat $L @L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52840 FLOAT_ABI_SOFT NRF52811_XXAA NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT USE_APP_CONFIG LFS_DEFINES=lfs_defines.h
  c misc: --locale=english --reduce_paths
  c include: ..\;..\EPD;..\FS;..\GUI;..\SDK\17.1.0_ddde560;..\SDK\17.1.0_ddde560\components\ble\common;..\SDK\17.1.0_ddde560\components\ble\ble_advertising;..\SDK\17.1.0_ddde560\components\ble\nrf_ble_gatt;..\SDK\17.1.0_ddde560\components\ble\ble_services\ble_dfu;..\SDK\17.1.0_ddde560\components\libraries\atomic;..\SDK\17.1.0_ddde560\components\libraries\atomic_fifo;..\SDK\17.1.0_ddde560\components\libraries\atomic_flags;..\SDK\17.1.0_ddde560\components\libraries\balloc;..\SDK\17.1.0_ddde560\components\libraries\bootloader;..\SDK\17.1.0_ddde560\components\libraries\bootloader\ble_dfu;..\SDK\17.1.0_ddde560\components\libraries\bootloader\dfu;..\SDK\17.1.0_ddde560\components\libraries\delay;..\SDK\17.1.0_ddde560\components\libraries\fstorage;..\SDK\17.1.0_ddde560\components\libraries\fds;..\SDK\17.1.0_ddde560\components\libraries\experimental_section_vars;..\SDK\17.1.0_ddde560\components\libraries\log;..\SDK\17.1.0_ddde560\components\libraries\log\src;..\SDK\17.1.0_ddde560\components\libraries\memobj;..\SDK\17.1.0_ddde560\components\libraries\mutex;..\SDK\17.1.0_ddde560\components\libraries\pwr_mgmt;..\SDK\17.1.0_ddde560\components\libraries\ringbuf;..\SDK\17.1.0_ddde560\components\libraries\sortlist;..\SDK\17.1.0_ddde560\components\libraries\scheduler;..\SDK\17.1.0_ddde560\components\libraries\strerror;..\SDK\17.1.0_ddde560\components\libraries\svc;..\SDK\17.1.0_ddde560\components\libraries\timer;..\SDK\17.1.0_ddde560\components\libraries\util;..\SDK\17.1.0_ddde560\components\softdevice\common;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers\nrf52;..\SDK\17.1.0_ddde560\components\toolchain\cmsis\include;..\SDK\17.1.0_ddde560\external\fprintf;..\SDK\17.1.0_ddde560\external\segger_rtt;..\SDK\17.1.0_ddde560\integration\nrfx;..\SDK\17.1.0_ddde560\integration\nrfx\legacy;..\SDK\17.1.0_ddde560\modules\nrfx;..\SDK\17.1.0_ddde560\modules\nrfx\mdk;..\SDK\17.1.0_ddde560\modules\nrfx\drivers\include;..\SDK\17.1.0_ddde560\modules\nrfx\hal
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52840 FLOAT_ABI_SOFT NRF52811_XXAA NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=7 S112 SOFTDEVICE_PRESENT __STARTUP_CONFIG
  asm misc: --cpreproc --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DCONFIG_GPIO_AS_PINRESET,-DDEVELOP_IN_NRF52840,-DFLOAT_ABI_SOFT,-DNRF52811_XXAA,-DNRFX_COREDEP_DELAY_US_LOOP_CYCLES=3,-DNRF_SD_BLE_API_VERSION=7,-DS112,-DSOFTDEVICE_PRESENT,-D__STARTUP_CONFIG=__STARTUP_CONFIG
  asm include: ..\;..\config;..\EPD;..\GUI;..\SDK\17.1.0_ddde560;..\SDK\17.1.0_ddde560\components\ble\common;..\SDK\17.1.0_ddde560\components\ble\ble_advertising;..\SDK\17.1.0_ddde560\components\ble\nrf_ble_gatt;..\SDK\17.1.0_ddde560\components\libraries\atomic;..\SDK\17.1.0_ddde560\components\libraries\atomic_fifo;..\SDK\17.1.0_ddde560\components\libraries\atomic_flags;..\SDK\17.1.0_ddde560\components\libraries\balloc;..\SDK\17.1.0_ddde560\components\libraries\delay;..\SDK\17.1.0_ddde560\components\libraries\fstorage;..\SDK\17.1.0_ddde560\components\libraries\fds;..\SDK\17.1.0_ddde560\components\libraries\experimental_section_vars;..\SDK\17.1.0_ddde560\components\libraries\log;..\SDK\17.1.0_ddde560\components\libraries\log\src;..\SDK\17.1.0_ddde560\components\libraries\memobj;..\SDK\17.1.0_ddde560\components\libraries\mutex;..\SDK\17.1.0_ddde560\components\libraries\pwr_mgmt;..\SDK\17.1.0_ddde560\components\libraries\ringbuf;..\SDK\17.1.0_ddde560\components\libraries\sortlist;..\SDK\17.1.0_ddde560\components\libraries\scheduler;..\SDK\17.1.0_ddde560\components\libraries\strerror;..\SDK\17.1.0_ddde560\components\libraries\timer;..\SDK\17.1.0_ddde560\components\libraries\util;..\SDK\17.1.0_ddde560\components\softdevice\common;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers;..\SDK\17.1.0_ddde560\components\softdevice\s112\headers\nrf52;..\SDK\17.1.0_ddde560\components\toolchain\cmsis\include;..\SDK\17.1.0_ddde560\external\fprintf;..\SDK\17.1.0_ddde560\external\segger_rtt;..\SDK\17.1.0_ddde560\integration\nrfx;..\SDK\17.1.0_ddde560\integration\nrfx\legacy;..\SDK\17.1.0_ddde560\modules\nrfx;..\SDK\17.1.0_ddde560\modules\nrfx\mdk;..\SDK\17.1.0_ddde560\modules\nrfx\drivers\include;..\SDK\17.1.0_ddde560\modules\nrfx\hal
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x17000
  memory RVCT9: RAM 0x200022d8 size 0x3d28
  memory RVCT10: RAM 0x800000 size 0x6000
  link misc: --diag_suppress 6330
  group App
    ../: main.c app_config.h
    ../SDK/17.1.0_ddde560/: sdk_config.h
  group EPD
    ../EPD/: EPD_config.c EPD_driver.c EPD_service.c UC81xx.c SSD16xx.c
  group FS
    ../FS/: flash.c lfs.c lfs_util.c filesystem.c image.c
  group GUI
    ../GUI/: GUI.c Lunar.c fonts.c u8g2_font.c Adafruit_GFX.c
  group nRF_BLE
    ../SDK/17.1.0_ddde560/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../SDK/17.1.0_ddde560/components/ble/ble_advertising/: ble_advertising.c
    ../SDK/17.1.0_ddde560/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_DFU
    ../SDK/17.1.0_ddde560/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_unbonded.c
  group nRF_Drivers
    ../SDK/17.1.0_ddde560/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c
    ../SDK/17.1.0_ddde560/modules/nrfx/soc/: nrfx_atomic.c
    ../SDK/17.1.0_ddde560/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_spi.c nrfx_spim.c nrfx_wdt.c
    ../SDK/17.1.0_ddde560/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../SDK/17.1.0_ddde560/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../SDK/17.1.0_ddde560/components/libraries/scheduler/: app_scheduler.c
    ../SDK/17.1.0_ddde560/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../SDK/17.1.0_ddde560/components/libraries/fds/: fds.c
    ../SDK/17.1.0_ddde560/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../SDK/17.1.0_ddde560/components/libraries/atomic_flags/: nrf_atflags.c
    ../SDK/17.1.0_ddde560/components/libraries/atomic/: nrf_atomic.c
    ../SDK/17.1.0_ddde560/components/libraries/balloc/: nrf_balloc.c
    ../SDK/17.1.0_ddde560/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
    ../SDK/17.1.0_ddde560/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../SDK/17.1.0_ddde560/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../SDK/17.1.0_ddde560/components/libraries/memobj/: nrf_memobj.c
    ../SDK/17.1.0_ddde560/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../SDK/17.1.0_ddde560/components/libraries/ringbuf/: nrf_ringbuf.c
    ../SDK/17.1.0_ddde560/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../SDK/17.1.0_ddde560/components/libraries/sortlist/: nrf_sortlist.c
    ../SDK/17.1.0_ddde560/components/libraries/strerror/: nrf_strerror.c
    ../SDK/17.1.0_ddde560/components/libraries/hardfault/nrf51/handler/: hardfault_handler_keil.c
    ../SDK/17.1.0_ddde560/components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../SDK/17.1.0_ddde560/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../SDK/17.1.0_ddde560/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../SDK/17.1.0_ddde560/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group Startup
    ../SDK/17.1.0_ddde560/modules/nrfx/mdk/: arm_startup_nrf52811.s system_nrf52.c
target flash_softdevice (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: as above
  output: s112_nrf52_7.3.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: BLE_STACK_SUPPORT_REQD NRF51822 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x19000 size 0x17000
  memory RVCT9: RAM 0x200022c8 size 0x3d38
  memory RVCT10: RAM 0x800000 size 0x6000
